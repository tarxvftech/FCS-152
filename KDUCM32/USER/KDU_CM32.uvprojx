# Keil uVision project KDU_CM32.uvprojx, settings and files
target KDU_Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CM32M101A-L64 CMIOT
  pack: China Mobile IOT Company Limited(CMIOT).CM32M101A_DFP.0.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KDU_Bootloader +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin !L -o ..\Bin\@L.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CM32M101A, USE_STDPERIPH_DRIVER
  c include: ..\LIB\core;..\LIB\device;..\LIB\cm32m101a_algo_lib\inc;..\LIB\cm32m101a_usbfs_driver\inc;..\LIB\cm32m101a_std_periph_driver\inc;..\DRV\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../LIB/device/: system_cm32m101a.c
    ../LIB/device/startup/: startup_cm32m101a.s
  group LIB
    ../LIB/cm32m101a_std_periph_driver/src/: cm32m101a_crc.c cm32m101a_flash.c cm32m101a_gpio.c cm32m101a_iwdg.c cm32m101a_rcc.c cm32m101a_tim.c cm32m101a_usart.c misc.c
  group BSP
    ../LIB/device/: cm32m101a_conf.h
    ../DRV/: main.h bsp_delay.c bsp_flash.c bsp_uart.c bsp_lcd.c font.c font_base.c
    ../DRV/inc/: FCS152_KDU.h userinclude.h
  group DRV
    ../DRV/: mainBootloader.c mainAPP.c function_152.c tim.c lcd.c key.c iap.c
target KDU_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CM32M101A-L64 CMIOT
  pack: China Mobile IOT Company Limited(CMIOT).CM32M101A_DFP.0.1.1
  cpu: as above
  output: KDU_APP +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin !L -o ..\Bin\@L.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CM32M101A, USE_STDPERIPH_DRIVER,KDUAPP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
